# Keil uVision project stm32c031c6-embedded-template.uvprojx, settings and files
target dbg (6240000::V6.24::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: stm32c031c6-embedded-template
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c misc: -Wno-declaration-after-statement
  c include: ..\nucleo-c031c6;..\CMSIS\Include;.\include\app;.\include\board;.\include\drivers
  asm define: Stack_Size=2048,Heap_Size=0
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: stm32c031c6-embedded-template.sct
  group App
    ./src/app/: main.c
    ./include/app/: main.h
  group Board
    ./src/board/: bsp.c
    ./include/board/: bsp.h
  group Drivers
    ./src/drivers/: button.c uart.c systick.c
    ./include/drivers/: button.h uart.h
    ./include/app/: app_event.h
  group nucleo-c031c6
    ../nucleo-c031c6/: README.txt stm32c0xx.h stm32c031xx.h system_stm32c0xx.c system_stm32c0xx.h
    ../nucleo-c031c6/arm/: startup_stm32c031xx.s
  group CMSIS
    ../CMSIS/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm0plus.h
